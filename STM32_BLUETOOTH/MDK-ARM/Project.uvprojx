# Keil uVision project Project.uvprojx, settings and files
target Project (5060020::V5.06 (build 20)::ARMCC)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: STM32F4XX, USE_STDPERIPH_DRIVER
  c include: ..\..\STM32_BLUETOOTH;..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\CMSIS\Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../: stm32f4xx_it.c main.c
    ../../../Test_Bluetooth HC-06 - Android/Test_Bluetooth HC-06 - Android/cmsis_lib/source/: stm32f4xx_usart.c
  group CMSIS
    ../: system_stm32f4xx.c
  group MDK-ARM
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f4xx.s
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c misc.c stm32f4xx_rcc.c
